# The is automatic generated Code by "makePipRecipes.py"
# (build by Robin Sebastian (https://github.com/robseb) (git@robseb.de) Vers.: 1.2) 

SUMMARY = "Recipe to embedded the Python PiP Package pure_eval"
HOMEPAGE ="https://pypi.org/project/pure_eval"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=a3d6c15f7859ae235a78f2758e5a48cf"

inherit pypi python_setuptools_build_meta
PYPI_PACKAGE = "pure_eval"
SRC_URI[md5sum] = "212fd27ca2c58d9effddec69748d738a"
SRC_URI[sha256sum] = "2b45320af6dfaa1750f543d714b6d1c520a1688dec6fd24d339063ce0aaa9ac3"

BBCLASSEXTEND = "native"
